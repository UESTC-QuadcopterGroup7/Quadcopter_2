# Keil uVision project LED.uvprojx, settings and files
target Sample (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: T2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F401xE
  c include: .\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Inc;.\Firmware\Drivers;.\Firmware\Algorithms;.\Firmware\Control;.\Firmware\Communication;.\Firmware\Services;.\Port;.\Source;.\Config;.\ucCPU;.\ucLib;.\SEGGER\RTT;.\SEGGER\SystemView;.\SEGGER\Config;.\SEGGER\uCOS-II
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS_device_inc
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h stm32f401xc.h stm32f401xe.h stm32f405xx.h stm32f407xx.h stm32f410cx.h stm32f410rx.h stm32f410tx.h stm32f411xe.h stm32f412cx.h stm32f412rx.h stm32f412vx.h stm32f412zx.h stm32f415xx.h stm32f417xx.h stm32f427xx.h stm32f429xx.h stm32f437xx.h stm32f439xx.h stm32f446xx.h stm32f469xx.h stm32f479xx.h system_stm32f4xx.h
  group CMSIS_inc
    ./Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group CMSIS_dvice
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/: startup_stm32f401xe.s system_stm32f4xx.c
  group HAL_inc
    ./Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group HAL
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c
  group USER
    ./Src/: main.c stm32f4xx_it.c
  group Firmware Drivers
    ./Firmware/Drivers/: GPIO_Set.h PWM_Set.h MyI2C.c Delay.c Delay.h MyI2C.h GY86.c GY86.h OLED.c OLED.h OLED_Font.h USART_Set.h UART_Set.h BLDC.c BLDC.h Receive_IC.c Receive_IC.h
  group Firmware Algorithms
    ./Firmware/Algorithms/: AccelCalibration.c AccelCalibration.h PID.c PID.h Quaternion.c Quaternion.h Attitude.c Attitude.h
  group Firmware Control
    ./Firmware/Control/: RC_Config.h RC_Control.c RC_Control.h FlightControl.c FlightControl.h FlightControlConfig.h
  group Firmware Communication
    ./Firmware/Communication/: ANO.c ANO.h
  group Firmware Services
    ./Firmware/Services/: ReadPeripherals.c ReadPeripherals.h
  group uCOS-II_Port
    ./Port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-II_Source
    ./Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_dbg_r.c
  group uCOS-II_Config
    ./Config/: app_cfg.h app_hooks.c os_cfg.h
  group uC-CPU
    ./ucCPU/: cpu.h cpu_a.asm cpu_c.c cpu_cache.h cpu_core.c cpu_core.h cpu_def.h cpu_cfg.h
  group uC-Lib
    ./ucLib/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group SEGGER_RTT
    ./SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_ConfDefaults.h
    ./SEGGER/Config/: SEGGER_RTT_Conf.h
  group SEGGER_SystemView
    ./SEGGER/SystemView/: SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Int.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER.h
    ./SEGGER/Config/: SEGGER_SYSVIEW_Conf.h Global.h
  group SEGGER_SystemView_Staged
    ./SEGGER/uCOS-II/: SEGGER_SYSVIEW_Config_Quadcopter.c SEGGER_SYSVIEW_uCOSII.c os_trace_events.h os_cfg_trace.h
